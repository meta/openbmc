SERIAL_CONSOLES = "9600;ttyS0"
