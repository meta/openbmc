SERIAL_CONSOLES:nexthopbmc = "9600;ttyS4"
