EXTRA_OEMESON:append = " -Dupdate-ebr-init=enabled"

